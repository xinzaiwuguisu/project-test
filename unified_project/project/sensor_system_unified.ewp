# IAR project sensor_system_unified.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  ICCARM.CCDefines: DEBUG; STM32F103xB; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\include; ..\src
  ICCARM.CCOptLevel: 0
  ICCARM.IccLang: 0
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F103xB; USE_STDPERIPH_DRIVER
  ICCARM.CCOptLevel: 3
  group Application
    ../src/: main.c
  group Sensor
    ../src/: sensor_data.c
    ../include/: sensor_data.h
  group Database
    ../src/: database.c
    ../include/: database.h
  group Communication
    ../src/: communication.c
    ../include/: communication.h
  group Configuration
    ../include/: config.h
