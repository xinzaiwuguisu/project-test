# IAR project sensor_system_iar53_fixed.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  ICCARM.CCDefines: DEBUG; STM32F103xB; USE_STDPERIPH_DRIVER; IAR_VERSION_53
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\src
  ICCARM.CCOptLevel: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sensor_system.srec
  XLINK.XLinkStackSize: 1
  group Source
    ../src/: main.c sensor_data.c database.c communication.c
  group Header
    ../src/: config.h sensor_data.h database.h communication.h
