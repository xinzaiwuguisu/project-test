# IAR project minimal_iar53.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  ICCARM.CCDefines: DEBUG; STM32F103xB; IAR_VERSION_53
  ICCARM.CCIncludePath2: ..\src
  ICCARM.CCOptLevel: 0
  ICCARM.IccLang: 0
  group Source
    ../src/: main.c sensor_data.c database.c communication.c
