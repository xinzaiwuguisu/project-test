# IAR project sensor_system.ewp, settings and files
configuration Debug (ARM, debug)
  ICCARM.CCDefines: DEBUG=1; STM32F103xB
  ICCARM.CCIncludePath2: ..\src
  ICCARM.CCOptLevel: 0
  ILINKARM.IlinkOutputFile: sensor_system.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG=1; STM32F103xB
  ICCARM.CCOptLevel: 3
  group Source Files
    ../src/: main.c sensor_data.c database.c communication.c
  group Header Files
    ../src/: config.h sensor_data.h database.h communication.h
